<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\pca10028\s130\iar\ble_app_uart_pca10028_s130.ewp</path>
  </project>
  <batchBuild/>
</workspace>


