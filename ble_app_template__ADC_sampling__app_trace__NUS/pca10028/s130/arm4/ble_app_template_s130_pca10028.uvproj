# Keil uVision project ble_app_template_s130_pca10028.uvproj, settings and files
target nrf51422_xxac_s130 (ARM-ADS)
  device: nRF51422_xxAC Nordic Semiconductor
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(16000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: nrf51422_xxac_s130 +hex
  c flags: Optim=4 OneElfS=1
  c define: BLE_STACK_SUPPORT_REQD S130 BOARD_PCA10028 SOFTDEVICE_PRESENT NRF51 SWI_DISABLE0 ENABLE_DEBUG_LOG_SUPPORT
  c misc: --c99
  c include: ..\..\..\config;..\..\..\..\..\..\components\softdevice\s130\headers;..\..\..\..\..\bsp;..\..\..\..\..\..\components\ble\common;..\..\..\..\..\..\components\ble\ble_advertising;..\..\..\..\..\..\components\device;..\..\..\..\..\..\components\toolchain;..\..\..\..\..\..\components\libraries\util;..\..\..\..\..\..\components\libraries\button;..\..\..\..\..\..\components\drivers_nrf\gpiote;..\..\..\..\..\..\components\drivers_nrf\config;..\..\..\..\..\..\components\drivers_nrf\common;..\..\..\..\..\..\components\drivers_nrf\hal;..\..\..\..\..\..\components\ble\device_manager;..\..\..\..\..\..\components\softdevice\common\softdevice_handler;..\..\..\..\..\..\components\libraries\timer;..\..\..\..\..\..\components\libraries\trace;..\..\..\..\..\..\components\drivers_nrf\pstorage;..\..\..\..\..\..\components\drivers_nrf\uart;..\..\..\..\..\..\components\ble\ble_services\ble_nus;..\..\..\..\..\..\components\libraries\fifo
  asm define: BLE_STACK_SUPPORT_REQD S130 BOARD_PCA10028 SOFTDEVICE_PRESENT NRF51 SWI_DISABLE0
  library: MicroLIB
  memory RVCT4: ROM 0x1c000 size 0x24000
  memory RVCT9: RAM 0x20002800 size 0x5800
  group Application
    ../../../: main.c
  group Board Support
    ../../../../../bsp/: bsp.c bsp_btn_ble.c
  group Device
    ../../../../../../components/toolchain/arm/: arm_startup_nrf51.s
    ../../../../../../components/toolchain/: system_nrf51.c
  group Documentation
    ../../../: Abstract.txt license.txt
  group nRF_BLE
    ../../../../../../components/ble/common/: ble_advdata.c ble_conn_params.c ble_srv_common.c
    ../../../../../../components/ble/ble_advertising/: ble_advertising.c
    ../../../../../../components/ble/device_manager/: device_manager_peripheral.c
    ../../../../../../components/ble/ble_services/ble_nus/: ble_nus.c
  group nRF_Drivers
    ../../../../../../components/drivers_nrf/hal/: nrf_delay.c
    ../../../../../../components/drivers_nrf/common/: nrf_drv_common.c
    ../../../../../../components/drivers_nrf/gpiote/: nrf_drv_gpiote.c
    ../../../../../../components/drivers_nrf/pstorage/: pstorage.c
    ../../../../../../components/drivers_nrf/uart/: app_uart_fifo.c
  group nRF_Libraries
    ../../../../../../components/libraries/button/: app_button.c
    ../../../../../../components/libraries/util/: app_error.c nrf_assert.c
    ../../../../../../components/libraries/timer/: app_timer.c
    ../../../../../../components/libraries/trace/: app_trace.c
    ../../../../../../components/libraries/uart/: retarget.c
    ../../../../../../components/libraries/fifo/: app_fifo.c
  group nRF_SoftDevice
    ../../../../../../components/softdevice/s130/doc/: s130_nrf51822_1.0.0_licence_agreement.txt
    ../../../../../../components/softdevice/common/softdevice_handler/: softdevice_handler.c
target flash_softdevice (ARM-ADS)
  device: nRF51422_xxAC Nordic Semiconductor
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x8000) CPUTYPE("Cortex-M0") CLOCK(16000000) ELITTLE
  output: s130_softdevice.hex +hex
  c flags: Optim=4 OneElfS=1
  c define: BLE_STACK_SUPPORT_REQD
  c misc: --c99
  c include: ..\..\..\config
  asm define: BLE_STACK_SUPPORT_REQD
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
